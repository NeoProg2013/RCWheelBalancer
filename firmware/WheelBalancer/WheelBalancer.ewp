# IAR project WheelBalancer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103x6
  ICCARM.CCIncludePath2: drivers\CMSIS\core; drivers\CMSIS\device\STM32F1xx; drivers\CMSIS\inc; drivers\HAL; drivers\HAL\legacy; drivers; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WheelBalancer.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: drivers\CMSIS\device\STM32F1xx\iar\linker\stm32f103x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group drivers/CMSIS/core
    drivers/CMSIS/core/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h irq_ctrl.h mpu_armv7.h mpu_armv8.h tz_context.h
  group drivers/CMSIS/device/STM32F1xx
    drivers/CMSIS/device/STM32F1xx/: stm32f103x6.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group drivers/CMSIS/device/STM32F1xx/iar
    drivers/CMSIS/device/STM32F1xx/iar/: startup_stm32f103x6.s
  group drivers/CMSIS/inc
    drivers/CMSIS/inc/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group drivers/HAL
    drivers/HAL/: stm32_assert_template.h stm32f1xx_hal.c stm32f1xx_hal.h stm32f1xx_hal_adc.c stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.c stm32f1xx_hal_can.h stm32f1xx_hal_cec.c stm32f1xx_hal_cec.h stm32f1xx_hal_conf.h stm32f1xx_hal_cortex.c stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.c stm32f1xx_hal_crc.h stm32f1xx_hal_dac.c stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.c stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.c stm32f1xx_hal_eth.h stm32f1xx_hal_exti.c stm32f1xx_hal_exti.h stm32f1xx_hal_flash.c stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.c stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.c stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.c stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.c stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.c stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.c stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.c stm32f1xx_hal_nand.h stm32f1xx_hal_nor.c stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.c stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.c stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.c stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.c stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.c stm32f1xx_hal_spi.h stm32f1xx_hal_sram.c stm32f1xx_hal_sram.h stm32f1xx_hal_tim.c stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.c stm32f1xx_hal_uart.h stm32f1xx_hal_usart.c stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.c stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.c stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.c stm32f1xx_ll_crc.h stm32f1xx_ll_dac.c stm32f1xx_ll_dac.h stm32f1xx_ll_dma.c stm32f1xx_ll_dma.h stm32f1xx_ll_exti.c stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.c stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.c stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.c stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.c stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.c stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.c stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.c stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.c stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.c stm32f1xx_ll_tim.h stm32f1xx_ll_usart.c stm32f1xx_ll_usart.h stm32f1xx_ll_usb.c stm32f1xx_ll_usb.h stm32f1xx_ll_utils.c stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
  group drivers/HAL/legacy
    drivers/HAL/legacy/: stm32_hal_legacy.h stm32f1xx_hal_can.c stm32f1xx_hal_can_ex_legacy.h stm32f1xx_hal_can_legacy.h
  group src
    src/: core.h main.cpp
